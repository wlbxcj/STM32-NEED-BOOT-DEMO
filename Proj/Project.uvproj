# Keil uVision project Project.uvproj, settings and files
target ST01 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM01 +hex
  AfterMake: fromelf --bin --output=obj\@L.bin obj\@L.axf
  c flags: OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Source\App;..\Source\BSP;..\Source\CMSIS;..\Source\FWlib\inc;..\Proj;..\Source\Starup;..\Source\uCOS_Ports;..\Source\uCOS_Source;..\Source\USER;..\Source\FWlib;..\Source\Driver
  memory RVCT4: ROM 0x8006000 size 0x7a000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\Source\USER\STM01.sct
  group Startup
    ../Source/Starup/: startup_stm32f10x_hd.s
  group User
    ../Source/App/: app_cfg.h
    ../Source/USER/: main.c stm32f10x_it.c includes.h config.h task.c
  group APP
    ../Source/App/: app.c app.h
  group CMSIS
    ../Source/CMSIS/: core_cm3.c system_stm32f10x.c
  group BSP
    ../Source/BSP/: BSP.c BSP.h
  group FWlib
    ../Source/FWlib/: stm32f10x_conf.c
  group uCOS_Source
    ../Source/uCOS_Source/: ucos_ii.c
  group uCOS_Ports
    ../Source/uCOS_Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Driver
    ../Source/Driver/: driver.c
